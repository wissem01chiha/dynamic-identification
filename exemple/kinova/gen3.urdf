Commit message: update code via git windows

File: exemple/kinova/gen3.urdf (robot description, URDF)
Before this commit: robot kinova_gen3, 10 links, 9 joints
Links:
- link base_link: mass  1.377 ->  1.477
